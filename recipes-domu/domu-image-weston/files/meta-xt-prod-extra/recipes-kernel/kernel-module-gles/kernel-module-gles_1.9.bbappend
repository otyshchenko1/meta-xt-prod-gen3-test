require inc/xt_shared_env.inc

PVRKM_URL = "git://git@gitpct.epam.com/epmd-aepr/pvr_km_vgpu_img.git"
BRANCH = "perf_opt"
SRCREV = "b93358a14e996d8fe9774ed8bd9171fe4e61c802"
