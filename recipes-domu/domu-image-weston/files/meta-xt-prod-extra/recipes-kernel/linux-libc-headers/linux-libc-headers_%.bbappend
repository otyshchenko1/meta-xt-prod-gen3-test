RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "master"
SRCREV = "c7996d63cf48edb65ad081596a4e93b7f66d7d4d"
LINUX_VERSION = "4.14.35"
