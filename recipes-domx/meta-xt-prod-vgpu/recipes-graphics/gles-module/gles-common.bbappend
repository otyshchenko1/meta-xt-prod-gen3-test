COMPATIBLE_MACHINE_append = "(|r8a77965)"

SRC_URI_r8a77965 = "${PVRUM_URL};protocol=ssh;branch=${BRANCH}"
PVRUM_BUILD_DIR_r8a77965 = "r8a77965_linux"
