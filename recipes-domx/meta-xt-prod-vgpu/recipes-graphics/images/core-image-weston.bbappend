IMAGE_INSTALL_append = " \
    kernel-modules \
"
