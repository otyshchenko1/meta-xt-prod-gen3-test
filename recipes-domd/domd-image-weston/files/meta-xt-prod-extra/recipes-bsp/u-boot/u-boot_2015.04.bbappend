SRC_URI_remove = "\
    file://0001-arm-renesas-Do-not-disable-MSTP3.patch \
"
