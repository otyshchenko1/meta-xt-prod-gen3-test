require inc/xt_shared_env.inc

BRANCH = "1.7/4563938-ces2018"
SRCREV = "${AUTOREV}"

EXTRA_OEMAKE += "SUPPORT_PVRSRV_GPUVIRT=1 PVRSRV_GPUVIRT_NUM_OSID=${XT_PVR_NUM_OSID}"

