RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "perf_opt"
SRCREV = "5c39f22dca28305bc4691313294b606ccb1da10d"
LINUX_VERSION = "4.14.35"
