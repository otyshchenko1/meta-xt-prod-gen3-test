################################################################################
# Renesas R-Car
################################################################################
SRCREV_rcar = "6769e73945566893c594d5f61929b63f821d6b87"

SRC_URI_append_rcar = " git://github.com/xen-troops/libxenbe.git;protocol=https;branch=master"
